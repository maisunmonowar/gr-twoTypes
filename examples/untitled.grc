options:
  parameters:
    generate_options: qt_gui
    id: testTwoTypes
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: twoTypes_passthrough_0
  id: twoTypes_passthrough
  parameters:
    someNumber: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', twoTypes_passthrough_0, '0']
- [twoTypes_passthrough_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
